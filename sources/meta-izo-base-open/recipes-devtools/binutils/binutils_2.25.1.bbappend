FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://0050-demangler-crash-on-casts-in-template-parameters.patch"

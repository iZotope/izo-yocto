FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://gamut-log-config.patch"

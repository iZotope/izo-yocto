FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://enable-ipv6-avahi-daemon.conf.patch"

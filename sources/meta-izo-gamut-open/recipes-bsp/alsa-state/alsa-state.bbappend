INITSCRIPT_PARAMS = "start 92 S . stop 31 0 6 ."
ALSASTATE_DIR := "${GAMUT_NV_LOCALSTATEDIR}"
